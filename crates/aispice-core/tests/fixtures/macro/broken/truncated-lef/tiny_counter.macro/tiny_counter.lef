# tiny_counter abstract. Synthetic test fixture.
VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MACRO tiny_counter
  CLASS BLOCK ;
  FOREIGN tiny_counter ;
  ORIGIN 0 0 ;
  SIZE 20 BY 10 ;
  PIN clk
    DIRECTION INPUT ;
    USE CLOCK ;
    PORT
      LAYER Metal2 ;
        RECT 0 2 0.4 2.8 ;
    END
  END clk
  PIN rst_n
    DIRECTION INPUT ;